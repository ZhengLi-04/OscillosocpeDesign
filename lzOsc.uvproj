# Keil uVision project lzOsc.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: lzOsc +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 global.c global.h main.c init.c init.h LED.c LED.h key.c key.h mode.c mode.h adc.c adc.h feature.c feature.h
